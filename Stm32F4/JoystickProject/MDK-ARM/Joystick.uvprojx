# Keil uVision project Joystick.uvprojx, settings and files
target SweepRobot (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: SweepRobot +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,ARM_MATH_CM4,__CC_ARM
  c misc: --locale=english
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Robot\RocRobotControl;..\Robot\RocRobotDriver\RocPca9685;..\Robot\RocRobotDriver\RocEeprom;..\Robot\RocRobotDriver\RocServo;..\Robot\RocRobotDriver\RocBluetooth;..\Robot\RocRobotDriver\RocLog;..\Robot\RocRobotDriver\RocError;..\Robot\RocRobotDriver\RocLed;..\Robot\RocRobotDriver\RocOled;..\Robot\RocRobotDriver\RocImu;..\Robot\RocRobotDriver\RocLcd;..\Robot\RocRobotDriver\RocZmod4410;..\Robot\RocRobotDriver\RocBeeper;..\Robot\RocRobotDriver\RocMotor;..\Robot\RocRobotDriver\RocBattery;..\Robot\RocRobotDriver\RocRemoteControl;..\Zmod4410\Inc;..\Zmod4410\Lib;..\Zmod4410\Src;..\USB\USBHost;..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\Middlewares\ST\STM32_USB_Host_Library\Core\Src;..\Middlewares\ST\STM32_USB_Host_Library\Class\HID\Inc;..\Middlewares\ST\STM32_USB_Host_Library\Class\HID\Src;..\Robot\RocRobotDriver\RocSimulatedI2c;..\Robot\RocRobotDriver\RocImu\RocMpu6050;..\Robot\RocRobotDriver\RocImu\RocMpu6050\eMPL;..\Robot\RocRobotDriver\RocTftLcd;..\Robot\RocRobotDriver\RocOled;..\Robot\RocRobotDriver\RocRelay
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Application/Robot
    ../Robot/RocRobotControl/: RocRobotControl.c RocRobotDhAlgorithm.c
  group Application/User
    ../Src/: main.c gpio.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c adc.c usb_host.c usbh_conf.c
    ../Robot/RocRobotDriver/RocUsb/: mouse.c keyboard.c menu.c
  group Drivers/BSP
    ../Robot/RocRobotDriver/RocPca9685/: RocPca9685.c
    ../Robot/RocRobotDriver/RocBluetooth/: RocBluetooth.c
    ../Robot/RocRobotDriver/RocLog/: RocLog.c
    ../Robot/RocRobotDriver/RocServo/: RocServo.c
    ../Robot/RocRobotDriver/RocLed/: RocLed.c
    ../Robot/RocRobotDriver/RocBeeper/: RocBeeper.c
    ../Robot/RocRobotDriver/RocMotor/: RocMotor.c
    ../Robot/RocRobotDriver/RocBattery/: RocBattery.c
    ../Robot/RocRobotDriver/RocRemoteControl/: RocRemoteControl.c
    ../Robot/RocRobotDriver/RocImu/RocMpu6050/: RocMpu6050.c
    ../Robot/RocRobotDriver/RocTftLcd/: RocTftLcd.c RocFont.c
    ../Robot/RocRobotDriver/RocOled/: RocOled.c
    ../Robot/RocRobotDriver/RocSimulatedI2c/: RocSimulatedI2c.c
    ../Robot/RocRobotDriver/RocRelay/: RocRelay.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group Middlewares/DMP_Library
    ../Robot/RocRobotDriver/RocImu/RocMpu6050/eMPL/: inv_mpu_dmp_motion_driver.c inv_mpu.c
software components: CMSIS:CORE 5.0.0
